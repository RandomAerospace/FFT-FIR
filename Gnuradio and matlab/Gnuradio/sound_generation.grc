options:
  parameters:
    generate_options: qt_gui
    id: sound_generation
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: FFT_width
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: audio_samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: filter_taps
  id: variable
  parameters:
    value: 0.0,3.91423272958491e-05,0.00016111771401483566,0.00023045178386382759,-5.265924320343604e-19,-0.0006765274447388947,-0.001619801507331431,-0.0022652086336165667,-0.001878548413515091,2.5445738275162363e-18,0.003098480636253953,0.006234649568796158,0.0076286871917545795,0.005692294333130121,-5.6640931882675616e-18,-0.008039700798690319,-0.015270126983523369,-0.017811840400099754,-0.012775544077157974,9.23107011111516e-18,0.01702537015080452,0.03170659393072128,0.03648094832897186,0.02596897818148136,-1.2497603041364615e-17,-0.03480198606848717,-0.06582175940275192,-0.07777741551399231,-0.057708725333213806,1.4778789326954167e-17,0.09041142463684082,0.19801442325115204,0.30022338032722473,0.37348464131355286,0.4000932574272156,0.37348464131355286,0.30022338032722473,0.19801442325115204,0.09041142463684082,1.4778789326954167e-17,-0.057708725333213806,-0.07777741551399231,-0.06582175940275192,-0.03480198606848717,-1.2497603041364615e-17,0.02596897818148136,0.03648094832897186,0.03170659393072128,0.01702537015080452,9.23107011111516e-18,-0.012775544077157974,-0.017811840400099754,-0.015270126983523369,-0.008039700798690319,-5.6640931882675616e-18,0.005692294333130121,0.0076286871917545795,0.006234649568796158,0.003098480636253953,2.5445738275162363e-18,-0.001878548413515091,-0.0022652086336165667,-0.001619801507331431,-0.0006765274447388947,-5.265924320343604e-19,0.00023045178386382759,0.00016111771401483566,3.91423272958491e-05,0.0
  states: {}
- name: input_samp_rate
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: |-
      Audio input SPS: 1Msps, 12 bit audio
      Audio output: 12 bit audio, 4095 resoltuion
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: input_samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: Speakers(Senary Audio)
    samp_rate: audio_samp_rate
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: FFT_width
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '0'
    type: complex
    vlen: FFT_width
  states: {state: bypassed}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '5'
    vlen: FFT_width
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: FFT_width
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: input_samp_rate
    type: float
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: input_samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0_1
  id: blocks_throttle2
  parameters:
    samples_per_second: input_samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\STARGATE_user\Desktop\EE2026\project\Gnuradio and matlab\ABC_48k.wav
    repeat: 'True'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    comment: |-
      on the FPGA, this is excecuted after 1024samples are captured.

      FFT frequency resolution 12500/1024=12.2Hz
      update period= 50000/1024=0.02s  (~50Hz)
    fft_size: FFT_width
    forward: 'True'
    shift: 'True'
    type: float
    window: window.hann(1024)
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    comment: |-
      this  becomes 20 bits after FIR btw,
      12 bit audio data register+ 8 bit FIR coefficient register
    decim: '1'
    taps: filter_taps
    type: fff
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_samp_rate
    fc: '0'
    fftsize: '128'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_samp_rate
    fc: '0'
    fftsize: '64'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_samp_rate
    fc: '0'
    fftsize: '256'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: window.WIN_HANN
  states: {}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: window.WIN_HANN
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: input_samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: input_samp_rate
    type: float
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    name: FFT
    vlen: FFT_width
    x_start: '20'
    x_step: '1.0'
    ymin: '-150'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      If the input signal is at rate fs, 
      then the output signal will be at a rate of interpolation · fs / decimation.

      50ksps(25kHz BW)->decimate by 2=50/2=25kHz(12.5kHz BW)

      using 12.5kHz, we have a window of  +6.25KHz on the FFT drawing
    decim: '2'
    interp: '1'
    type: fff
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_throttle2_0, '0', fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_1_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_throttle2_0_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_throttle2_0_0, '0', qtgui_freq_sink_x_0_1, '0']
- [blocks_throttle2_0_1, '0', audio_sink_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle2_0, '0']
- [fft_vxx_0, '0', blocks_multiply_const_xx_0, '0']
- [fir_filter_xxx_0, '0', blocks_throttle2_0_1, '0']
- [fir_filter_xxx_0, '0', qtgui_freq_sink_x_1, '0']
- [fir_filter_xxx_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
